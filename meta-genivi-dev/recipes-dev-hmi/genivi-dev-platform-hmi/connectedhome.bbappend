SRC_URI = "git:///github.com/tizenhelper/connected-home;protocol=http;nobranch=1"
SRCREV = "sandbox/pcoval/on/master/devel"
