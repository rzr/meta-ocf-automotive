require recipes-dev-platform/images/genivi-dev-platform.bb

IMAGE_INSTALL += " packagegroup-ocf-automotive"
IMAGE_INSTALL += " iotivity-example-demo"

