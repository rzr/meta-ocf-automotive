IMAGE_INSTALL += " packagegroup-ocf-automotive"
