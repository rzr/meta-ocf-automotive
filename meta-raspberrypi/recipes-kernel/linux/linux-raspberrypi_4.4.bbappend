# http://unix.stackexchange.com/questions/308811/autoload-a-kernel-module-in-yoc

KERNEL_MODULE_AUTOLOAD += "i2c-dev"
ENABLE_I2C = "1"
