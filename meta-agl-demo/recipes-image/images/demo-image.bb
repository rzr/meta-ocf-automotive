require recipes-core/images/core-image-minimal-dev.bb
IMAGE_INSTALL += " packagegroup-ocf-automotive"
