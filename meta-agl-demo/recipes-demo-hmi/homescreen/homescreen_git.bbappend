PR = "r1"
SRCREV  = "sandbox/pcoval/on/master/devel"
SRC_URI = "git://github.com/TizenTeam/AGL-HomeScreen;nobranch=1;protocol=http \
           file://dbus-homescreen.conf.in"

